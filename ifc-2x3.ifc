Properties of the parts of a building model (IFC2X3)

# File
Description: Frostschutz-Thermostat, Kapillarlänge 12 m, Außeneinstellung, 2-stufig, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6090330, Frostschutz-Thermostat, Kapillarlänge 12 m, Außeneinstellung, 2-stufig
In: Raum
Description: Zur Sicherung von Warmwasserheizregistern gegen Einfrieren. Das Gerät ist eigensicher und hat eine plombierbare Sollwerteinstellung. Für Temperaturmessung nicht aggressiver Gase. Der Frostschutzwächter JTF-21 verfügt über 2 Schaltausgänge, wodurch vor Erreichen des Gefahrenpunktes bereits Eingriffe in das System möglich sind. Zum Verspannen des Kapillars vor dem Heizregister sind die Montageklammern JZ-05/6M (Metall) oder JZ-05/6 K (Kunststoff) zu verwenden. Das Kapillar ist auf der ganzen Länge aktiv. Das Gerät spricht an, wenn ca. 60 cm Kapillar den eingestellten Skalenwert erreicht. Montageklammern, Tauchhülsen und Schutzwendel gehören nicht zum Lieferumfang und müssen separat bestellt werden. Die Hysterese zwischen den Stufen beträgt ca. 5 K.; Classification: EC011174 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6090330; ModelLabel: JTF-21/12; GlobalTradeItemNumber: 4050528030641; ProductURL: https://alre.de/produkt_E6090330
Pset_Specification - NominalLength: 0.112 m; NominalWidth: 0.105 m; NominalDepth: 0.055 m; NetWeight: 0.764
Pset_ALRE_ETIM_Properties - Breite: 105; Höhe: 112; Tiefe: 55; Messbereich: 10; Explosionsgeschützt: no; Schutzart (IP): IP40; Max. Mediumtemperatur (Dauerbetrieb): 200; Länge Kapillar: 12; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 15; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011174; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6090330.pdf
